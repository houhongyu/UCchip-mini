# Keil uVision project STM32-FD.uvprojx, settings and files
target STM32-FD (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-FD +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\FWlib\inc;.\user;.\CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./user/: stm32f10x_it.c
    ./startup/: startup_stm32f10x_hd.s
    ./FWlib/inc/: stm32f10x_tim.h
  group user
    ./user/: main.c light.c distance.c DHT11.c sys.h
  group FWLIB
    ./FWlib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_tim.c
  group readme
    ./: readme.txt
  group CMSYS
    ./CM3/: core_cm3.c system_stm32f10x.c
    ./FWlib/inc/: stm32f10x_tim.h
